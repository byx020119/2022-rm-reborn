# Keil uVision project Sentry.uvprojx, settings and files
target Sentry (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sentry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: .\BSP;.\COMMON;.\CORE;.\STLibraries\inc;.\TASK;.\USER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP
    ./BSP/: bsp.c can2.c can1.c gun.c timer.c usart1.c usart3.c adc.c usart6.c usart7.c
  group ControlTask
    ./TASK/: Freedom_Status.c SpeedTask.c ControlTask.c WorkState.c ShootingTask.c GunHeartAndBleed.c JudgingSystemTask.c Phototube.c Doget_state.c RM_Cilent_UI.c
  group CanBusTask
    ./TASK/: CanBusTask.c encoder.c
  group RemoteTask
    ./TASK/: RemoteTask.c InputState.c
  group COMMON
    ./COMMON/: common.c crc.c pid.c ramp.c kalman.c
  group STLIB
    ./STLibraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
  group CORE
    ./CORE/: startup_stm32f427xx.s
  group TEXT
    ./TEXT/: text.txt
